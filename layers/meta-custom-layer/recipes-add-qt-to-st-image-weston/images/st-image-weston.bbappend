FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://add-sdk-inheritance.patch"


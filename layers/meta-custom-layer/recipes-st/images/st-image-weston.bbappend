# File: /layers/meta-custom-layer/recipes-st/images/st-image-weston.bbappend

inherit populate_sdk
inherit populate_sdk_qt5

#FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI += "file://add-sdk-inheritance.patch"


FILESEXTRAPATHS:prepend := "${THISDIR}/linux-stm32mp:"

SRC_URI:append = " file://stm32mp25-eth.cfg"